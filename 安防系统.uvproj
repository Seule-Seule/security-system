# Keil uVision project 安防系统.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 安防系统 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
  group lcd1602
    ./: lcd.c lcd.h
  group beep
    ./: beep.h
  group dht11
    ./: dht11.h dht11.c
  group delay
    ./: delay.h delay.c
  group flame
    ./: flame.h
  group MQ-2
    ./: MQ-2.h
  group hc-sr
    ./: hr-sr.h
