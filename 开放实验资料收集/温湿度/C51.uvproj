# Keil uVision project C51.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: C51 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\HARDWARE\1602;.\HARDWARE\DHT11;.\HARDWARE\DS1302;.\HARDWARE\TIMER
  group Source Group 1
    ./: STARTUP.A51
    ./user/: c51.c
    ./HARDWARE/1602/: 1602.c
    ./HARDWARE/DHT11/: dht11.c
    ./HARDWARE/TIMER/: TIMER.C
