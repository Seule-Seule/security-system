# Keil uVision project DHT11.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Test-LED-BELL-TranLed
  group Source Group 1
    ./: main.c dht11.c Delay.c
